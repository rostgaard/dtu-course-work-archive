# IAR project MyProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCIncludePath2: Application; System; uip; uip\httpd
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: MyProject.srec
  ILINK.IlinkOutputFile: MyProject.out
  ILINK.IlinkIcfFile: config\LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    application/: clock-arch.c config.h includes.h main.c timer.c timer.h
    Application/: clock.h
  group Application/Conversion
    application/: adc.c adc.h dac.c dac.h filter.c filter.h frequency.c frequency.h gpio.c gpio.h interrupt_handlers.c interrupt_handlers.h zerocrossing.c zerocrossing.h
  group Application/LCD
    application/: Black_bg.c Black_bg.h button_lightgrey.c button_lightgrey.h button_relay_off_lightgrey.c button_relay_off_lightgrey.h cursor_arrow.c cursor_arrow.h drv_glcd.c drv_glcd.h drv_touch_scr.c drv_touch_scr.h photo.c photo.h Terminal_18_24x12.c Terminal_9_12x6.c touch_scr.c touch_scr.h
    ../../../Documents and Settings/guestusr/Desktop/31070 Utilities/: button_relay_on_lightgrey.c button_relay_on_lightgrey.h
  group Application/uIP
    uip/: lc-addrlabels.h lc-switch.h lc.h psock.c psock.h pt.h uip-timer.c uip-timer.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uiplib.c uiplib.h uipopt.h
  group Application/uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group Config
    config/: LPC2478_Flash.icf lpc2478_Flash.mac LPC2478_SRAM.icf lpc2478_SRAM.mac
  group System
    system/: arm_comm.h board.h LPC24xx_enet.c LPC24xx_enet.h sdram_32M_16bit_drv.c sdram_32M_16bit_drv.h sys.c sys.h
